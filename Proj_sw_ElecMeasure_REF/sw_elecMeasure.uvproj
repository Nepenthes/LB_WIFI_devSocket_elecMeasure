# Keil uVision project sw_elecMeasure.uvproj, settings and files
target WIFI开关_电参数测量_408AS影射版 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: sw_elecMeasure +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Proj_sw_ElecMeasure;.\Usr;.\Usr_lib;.\std_Lib;.\hwDriver;.\dataTrans
  link misc: REMOVEUNUSED
  group 用户文件
    ./Usr/: Usr_Main.c timerAct.c appTimer.c dataManage.c Tips.c usrKin.c
  group 数据传输
    ./dataTrans/: dataTrans.c
  group 驱动文件
    ./hwDriver/: HW8012.c wifi_LPT220.c Relay.c HYM8564.c
  group 外设库
    ./std_Lib/: Soft_UART.c delay.c USART.C EEPROM.c
  group 自定义方法
    ./Usr_lib/: pars_Method.c
